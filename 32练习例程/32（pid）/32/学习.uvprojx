# Keil uVision project 学习.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 学习 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\LIB\inc;.\LIB\src;.\STARTUP;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\Hardware\OLED;.\Hardware\LED;.\SYSTEM\rtc;.\SYSTEM\i2c;.\SYSTEM\adc;.\SYSTEM\nvic;.\Hardware\TTP229;.\Hardware\MLX90614;.\SYSTEM\tim;.\Hardware\LCD;.\Hardware;.\Hardware\OCIC;.\Hardware\PWM;.\Hardware\usart;.\Hardware;.\Hardware\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group LIB
    ./LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./STARTUP/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c common.h
  group SYSTM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/flash/: flash.c
    ./SYSTEM/i2c/: i2c.c
    ./SYSTEM/adc/: adc.c
    ./SYSTEM/nvic/: NVIC.c
    ./SYSTEM/tim/: tim.c
    ./SYSTEM/iwdg/: iwdg.c
    ./SYSTEM/spi/: spi.c
  group Hardware
    ./Hardware/OCIC/: timer.c
    ./Hardware/: protocol.c bsp_pid.c control.c
    ./Hardware/usart/: usart.c
    ./Hardware/PWM/: capture.c motor.c pwm.c
